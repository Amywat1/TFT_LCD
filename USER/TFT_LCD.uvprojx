# Keil uVision project TFT_LCD.uvprojx, settings and files
target TFT_LCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TFT_LCD +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10xx_FWLib\inc;..\HARDWARE;..\CORE
  asm define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/: led.c lcd.c
  group STSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10xx_FWLib/src/: stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
